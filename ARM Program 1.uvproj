# Keil uVision project ARM Program 1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ARM Program 1
  c flags: Optim=1
  group Source Group 1
    ./: ARM Signed Overflow.s
